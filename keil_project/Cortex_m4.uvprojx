# Keil uVision project Cortex_m4.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Cortex_m4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../Project_files/Application/: main.c
  group Public_Includes
    ../Project_files/Public_Includes/: stm32f407.h
  group MCAL
    ../Project_files/MCAL/GPIO/: MCAL_gpio.h MCAL_gpio.c
  group HAL
    ../Project_files/HAL/GPIO/: HAL_gpio.c HAL_gpio.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
